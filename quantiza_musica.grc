options:
  parameters:
    generate_options: qt_gui
    id: top_block
    output_language: python
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '8000'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: samp_rate
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: /Users/edmar/Documents/GitHub/PDS/handel.wav
    repeat: 'True'
  states: {}
- name: channels_quantizer_0
  id: channels_quantizer
  parameters:
    bits: '2'
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    showports: 'True'
    type: float
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}

connections:
- [blocks_wavfile_source_0, '0', channels_quantizer_0, '0']
- [channels_quantizer_0, '0', audio_sink_0, '0']
- [channels_quantizer_0, '0', qtgui_sink_x_0, '0']

metadata:
  file_format: 1
