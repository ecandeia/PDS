<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.13'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>f</value></param>
<param><key>value</key><value>2500</value></param>
<param><key>label</key><value>f</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>2000</value></param>
<param><key>step</key><value>200</value></param>
<param><key>stop</key><value>6000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>32000</value></param>
</block>
<block>
<key>fcd_source_c</key>
<param><key>id</key><value>fcd_source_c_0</value></param>
<param><key>dci</key><value>0.0</value></param>
<param><key>dcq</key><value>0.0</value></param>
<param><key>device_name</key><value>hw:1</value></param>
<param><key>freq</key><value>145500000</value></param>
<param><key>ppm</key><value>-120</value></param>
<param><key>iq_gain</key><value>1.0</value></param>
<param><key>iq_phase</key><value>0.0</value></param>
<param><key>lna</key><value>20.0</value></param>
<param><key>mixer</key><value>+12</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value></value></param>
<param><key>size</key><value>1024</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<connection><source_block_id>fcd_source_c_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
