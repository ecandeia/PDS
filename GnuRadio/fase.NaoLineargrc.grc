options:
  parameters:
    author: Leocarlos Bezerra da Silva Lima
    category: Custom
    description: Experimento para Laboratório de Princípios de Comunicações. Departamento de Engenharia Elétrica - DEE da Universidade Federal de Campina Grande - UFCG.
    generate_options: qt_gui
    id: Labo1_2
    output_language: python
    title: Geracao de sinal a partir de sua serie de Fourier
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '8000'
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: fundamental
  id: analog_sig_source_x
  parameters:
    amp: '1.0'
    freq: '100'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: graf_tempo_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    label1: ''
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: harmonica_1
  id: analog_sig_source_x
  parameters:
    amp: '1.0'
    freq: '200'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: harmonica_2
  id: analog_sig_source_x
  parameters:
    amp: '1.0'
    freq: '300'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    grid: 'True'
    showports: 'True'
    type: float
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: somador_0
  id: blocks_add_xx
  parameters:
    num_inputs: '3'
    type: float
  states: {}

connections:
- [blocks_throttle_0, '0', somador_0, '0']
- [fundamental, '0', blocks_throttle_0, '0']
- [harmonica_1, '0', somador_0, '1']
- [harmonica_2, '0', somador_0, '2']
- [somador_0, '0', graf_tempo_0, '0']
- [somador_0, '0', qtgui_freq_sink_x_0, '0']

metadata:
  file_format: 1
